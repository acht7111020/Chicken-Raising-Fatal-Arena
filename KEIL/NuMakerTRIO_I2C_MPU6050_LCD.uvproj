# Keil uVision project NuMakerTRIO_I2C_MPU6050_LCD.uvproj, settings and files
target MPU6050 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: NANO102SC2AN Nuvoton
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0x7FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: UART
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1
  c define: DEBUG_ENABLE_SEMIHOST
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\Nano1X2Series\Include;..\..\..\..\Library\NuMakerLib\Include;..\
  asm define: DEBUG_ENABLE_SEMIHOST
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_Nano1x2Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Nano1X2Series/Source/: system_Nano1X2Series.c
    ../../../../Library/Device/Nuvoton/Nano1X2Series/Source/ARM/: startup_Nano1X2Series.s
  group Libraries
    ../../../../Library/StdDriver/src/: sys.c clk.c uart.c gpio.c i2c.c rtc.c pwm.c adc.c timer.c
  group User
    ../: main.c
    ../../../../Library/NuMakerLib/Source/: I2Cdev.c MPU6050.c I2C_SSD1306Z.c SYS_init.c
